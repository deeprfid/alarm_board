# Keil uVision project hc32f4a0_boot.uvprojx, settings and files
target firmware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0PITB HDSC
  pack: HDSC.HC32F4A0.1.0.8
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f4a0_boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\boot\src;..\boot\inc;..\..\..\driver_lib\inc;..\..\..\hc32f4a0_app\projects\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\hc32f4a0_app\projects\cmsis\Include;..\..\..\driver_lib
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\boot.sct
  link misc: --keep=*Handler
  group boot
    ../boot/src/: boot_main.c ota_boot.c boot_qspi.c hc32_ll_efm.c
  group cmsis
    ../boot/src/: system_hc32f4a0.c startup_hc32f4a0.s
  group applib
    ../boot/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_utility.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.8.0, Security:mbed TLS 2.28.0, Data Exchange:JSON:cJSON 1.7.7
