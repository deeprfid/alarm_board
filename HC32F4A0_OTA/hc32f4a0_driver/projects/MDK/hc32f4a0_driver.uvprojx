# Keil uVision project hc32f4a0_driver.uvprojx, settings and files
target hc32f4a0_driver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0PITB HDSC
  pack: HDSC.HC32F4A0.1.0.8
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f4a_driver (library)
  AfterMake: xcopy .\output\hc32f4a_driver.lib  ..\..\..\driver_lib /Y
  AfterMake: xcopy .\hc32f46_driver.h  ..\..\..\driver_lib /Y
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEBUG,HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\source;..\..\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\..\drivers\cmsis\Include;..\..\drivers\hc32_ll_driver\inc;..\..\drivers\bsp\ev_hc32f4a0;..\DHCP;..\DNS;..\SNTP;..\user\inc;..\wizchip;..\wizchip\W5100S;..\..\projects;..\rtos2_help;..\..\drivers\cmsis;..\usb_lib\device_class\custom_hid;..\usb_lib\device_class\hid_cdc_composite;..\usb_lib\device_class\single_cdc;..\usb_lib\device_core;..\usb_lib\examp;..\usb_lib;..\usb_lib\usb_core;..\usb_lib\device_class\hid_keyboard;..\usb_lib\device_class\hid_mouse;..\usb_lib\device_class\msc;..\usb_lib\device_class\winusb;..\usb_lib\device_class\cdc_msc_composite;..\usb_lib\device_class\hid_msc_composite;..\MDK;..\jsonlib;..\..\..\driver_lib
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  link misc: --keep=*Handler
  group cmsis
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
  group source
    ../source/: qspi_flash.c bsp_gpio.c timer2.c ring_buf.c aes.c flash.c hash.c hash_hmac.c otp.c wdt.c crc_acc.c crc_encode.c timera.c bsp.c Retarget.c
  group driver
    ../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_usb.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_trng.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_crc.c hc32_ll_dma.c hc32_ll_event_port.c hc32_ll_hash.c hc32_ll_hrpwm.c hc32_ll_rmu.c hc32_ll_spi.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr2.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_wdt.c hc32_ll_adc.c hc32_ll_ots.c hc32_ll_mpu.c
  group bsp
    ../source/: board.c
  group user
    ../user/src/: uart1.c uart2.c uart3.c uart4.c usart_driver.c custom_ee_commond.c license.c main.c hw_init.c readercfg.c usr_mod.c wiegand.c timer.c io_stream.c irq.c pio.c common.c os_dep.c usb_utility.c trng.c bsp_i2c_gpio.c bsp_key.c bsp_led.c rs485_1.c rs485_2.c rs485_3.c bsp_pwm.c
    ./: hc32f46_driver.h
  group wizchip
    ../wizchip/: port.c socket.c wizchip_conf.c
    ../wizchip/W5100S/: w5100s.c
  group rtos2_help
    ../rtos2_help/: RTX_Config.c rtx_lib.c RTX_Config.h RTX_CM4F.lib
    ../../../driver_lib/: ModuleAPI_C_ARM.lib
  group DHCP
    ../DHCP/: dhcp.c
  group DNS
    ../DNS/: dns.c
  group FTPClient
    ../FTPClient/: ftpc.c
  group usb_lib
    ../usb_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
    ../usb_lib/examp/: usb_dev_desc.c usb_dev_user.c cdc_data_process.c usb_bsp.c
    ../usb_lib/device_class/single_cdc/: usb_dev_cdc_class.c
    ../usb_lib/device_class/custom_hid/: usb_dev_custom_hid_class.c
    ../usb_lib/device_class/hid_keyboard/: usb_dev_keyboard_class.c
    ../usb_lib/device_class/hid_mouse/: usb_dev_mouse_class.c
    ../usb_lib/device_class/msc/: usb_dev_msc_bot.c usb_dev_msc_class.c usb_dev_msc_data.c usb_dev_msc_scsi.c usb_dev_msc_qspi.c
    ../usb_lib/device_class/winusb/: usb_dev_winusb_class.c
    ../usb_lib/device_class/cdc_msc_composite/: usb_dev_cdc_msc_wrapper.c
    ../usb_lib/device_class/hid_cdc_composite/: usb_dev_hid_cdc_wrapper.c
    ../usb_lib/device_class/hid_msc_composite/: usb_dev_hid_msc_wrapper.c
  group SNTP
    ../SNTP/: sntp.c
  group ff16
    ../ff16/: ff.c ffsystem.c ffunicode.c diskio.c
