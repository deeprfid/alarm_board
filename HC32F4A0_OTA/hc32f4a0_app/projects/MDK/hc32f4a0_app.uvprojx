# Keil uVision project hc32f4a0_app.uvprojx, settings and files
target firmware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0PITB HDSC
  pack: HDSC.HC32F4A0.1.0.8
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEBUG,HC32F4A0,USE_DDL_DRIVER,__SCM__,_RTE_,ARM_MATH_LOOPUNROLL,ARM_MATH_CM4
  c misc: --diag_suppress=186,66
  c include: ..\middleware;..\app\src;..\app\inc;..\jsonlib;..\app\inc;..\..\..\driver_lib;..\cmsis\Device\HDSC\hc32f4xx\Include;..\MQTT\MQTTPacket\src;..\..\..\driver_lib\inc;..\MQTT;..\jsonlib;..\cmsis\Include;..\flashDB\include;E:\Keil_v5\Packs\ARM\CMSIS-DSP\1.16.2\Include
  memory RVCT4: ROM 0x10000 size 0xe0000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F4A0xI.sct
  link misc: --keep=*Handler
  group cmsis
    ../cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
    ../cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
  group user
    ../app/src/: customcmd.c ErrChecker.c event_mq.c msg_bus.c http_callback.c user_main.c ipc.c Lan2Uart.c modbus_mode.c reader_init.c reader_msg.c static_conf.c hc32_ll_efm.c stream_epc_scanner.c hwport.c List.c alarm.c tag_csv.c wl_dedup.c task_monitor.c EPC_TagStorage.c kalman_filter.c MobileNET.c rfid_processor.c tagdebug.c ota_agent.c usb_msc_ota.c ota_download.c ota_state.c ota_storage.c ota_transport_uart.c ota_frame.c ota_host.c radar_ota.c radar_link.c ota_dist.c ota_flag.c ota_security.c ota_usb.c rdr_cfg_kv.c ota_usb_stream.c ota_http.c ota_integration.c
    ../../../driver_lib/: hc32f46_driver.h
  group mqtt
    ../MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../MQTT/: mqtt_interface.c MQTTClient.c
  group httpapi
    ../app/src/: APIHttpRequest.cpp APIHttpResponse.cpp httpAPI.cpp HttpModuleAPI.cpp TAGINFOBuffer.cpp Utility.cpp
  group Jsonlib
    ../middleware/: http_parser.c
    ../jsonlib/: json_api.c TagBuffer.c
  group applib
    ../../../driver_lib/: ModuleAPI_C_ARM.lib hc32f4a_driver.lib RTX_CM4F.lib
  group flashdb
    ../flashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group fal
    ../flashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../flashDB/port/fal/samples/porting/: fal_flash_sfud_port.c
  group tagdb
    ../flashDB/samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
    ../flashDB/: flashdb.c QSPI_Sync.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.8.0, Security:mbed TLS 2.28.0, Data Exchange:JSON:cJSON 1.7.7
